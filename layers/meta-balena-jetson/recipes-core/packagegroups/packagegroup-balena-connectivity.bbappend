CONNECTIVITY_FIRMWARES:append = " \
    tegra-firmware-rtl8822 \
    linux-firmware-rtl8168 \
    linux-firmware-iwlwifi-8265 \
    linux-firmware-ath10k \
    linux-firmware-ath10k-license \
    linux-firmware-iwlwifi-ty-a0 \
"
