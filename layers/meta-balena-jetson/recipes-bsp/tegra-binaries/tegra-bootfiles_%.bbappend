COMPATBILE_MACHINE = "jetson-agx-orin-devkit"
PACKAGES = " ${PN} ${PN}-dev"
