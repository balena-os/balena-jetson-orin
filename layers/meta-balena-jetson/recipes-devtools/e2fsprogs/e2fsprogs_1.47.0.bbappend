FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-disable-metadata_csum_seed-and-orphan_file.patch "
