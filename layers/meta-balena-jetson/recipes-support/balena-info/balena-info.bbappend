TTYS = "ttyTCU0 tty0 tty1"
